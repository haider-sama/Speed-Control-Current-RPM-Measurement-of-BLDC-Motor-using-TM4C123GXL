# Keil uVision project MOTOR_CTRL_COMBINED_CODE.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Mid_Project_ES_II_45
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c BLDC_Motor_PWM.txt Full_Program_S1.txt UART.txt LCD.txt ADC0_AT_PE2.h RPM_CALCULATOR.h EVal_Task.txt
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
